void setup() {
  pinMode(2, INPUT);
  pinMode(4, OUTPUT);
  pinMode(5, OUTPUT);
  pinMode(6, OUTPUT);
  pinMode(7, OUTPUT);
  pinMode(8, OUTPUT);
  pinMode(9, OUTPUT);
  pinMode(10, OUTPUT);
  pinMode(11, OUTPUT);
  pinMode(12, OUTPUT);
  pinMode(13, OUTPUT);
  pinMode(A0, OUTPUT);
  pinMode(A1, OUTPUT);
  pinMode(A2, OUTPUT);
  attachInterrupt(digitalPinToInterrupt(2), toggle, CHANGE);
}

bool  t;
bool  k;
void loop() {
  if (k) {
    delay(100);
    k = 0;
  }
  digitalWrite(13, t);
}
void toggle() {
  
  if(k){}else
    if (digitalRead(2))
      if(t){t=0;}else t=1;
  k = 1;
}
