void setup() {
  pinMode(2, INPUT);
  pinMode(3, INPUT);
  pinMode(4, OUTPUT);
  pinMode(5, OUTPUT);
  pinMode(6, OUTPUT);
  pinMode(7, OUTPUT);
  pinMode(8, OUTPUT);
  pinMode(9, OUTPUT);
  pinMode(10, OUTPUT);
  pinMode(11, OUTPUT);
  pinMode(12, OUTPUT);
  pinMode(13, OUTPUT);
  pinMode(A0, OUTPUT);
  pinMode(A1, OUTPUT);
  pinMode(A2, OUTPUT);
  digitalWrite(A0, HIGH);
}
bool BLF = false;
void loop() {
  if (BLF) {
    if (digitalRead(2)) {
      delay(20);
    } else BLF = false;
  }else if (digitalRead(2)) {
    BLF = true;
    if (digitalRead(A0)) {
      digitalWrite(A0, LOW);
      digitalWrite(A1, HIGH);
    } else
    if (digitalRead(A1)) {
      digitalWrite(A1, LOW);
      digitalWrite(A2, HIGH);
    } else if (digitalRead(A2)) {
      digitalWrite(A2, LOW);
      digitalWrite(A0, HIGH);
    }
  }
}
