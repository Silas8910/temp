void setup() { 
  pinMode(2, INPUT);
  pinMode(3, INPUT); 
  pinMode(4,OUTPUT);
  pinMode(5,OUTPUT);
  pinMode(6,OUTPUT);
  pinMode(7,OUTPUT);
  pinMode(8,OUTPUT);
  pinMode(9,OUTPUT);
  pinMode(10,OUTPUT);
  pinMode(11,OUTPUT);
  pinMode(12,OUTPUT);
  pinMode(13,OUTPUT);
  pinMode(A0,OUTPUT);
  pinMode(A1,OUTPUT);
  pinMode(A2,OUTPUT);
}
bool BLF = false;
void loop() {
  if(BLF){if(digitalRead(2)){delay(20);return;}else BLF = false;}
  if(digitalRead(2)){
    BLF = true;
    if(digitalRead(8)){
      digitalWrite(8,LOW);
    }else
      digitalWrite(8,HIGH);
    delay(200);
  }
}
