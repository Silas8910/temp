int Phase[][5] = {{0,5,2,10,4},{1,5,2,5,0},{2,4,2,5,2},{2,3,2,10,4},{2,4,2,5,0},{2,5,1,5,3},{2,5,0,10,0},{2,5,1,5,0},{1,5,2,5,1}};
void setup() {
  Serial.begin(9600);
  DDRD = (DDRD&3) | B11110000;
  DDRB = B11111111;
  DDRC = B11111111;
  attachInterrupt(digitalPinToInterrupt(2),request,RISING);
  attachInterrupt(digitalPinToInterrupt(3),request,RISING);
}
volatile bool r;
void loop() {
  for(int i = 0; i < 9;i++){
    if(Phase[i][4]>0&&r){
      Serial.print("HI2");
      r=0;
      PORTD = (PORTD & B00001111) | B10100000;
      PORTB = B00100100;
      PORTC = B00000100;
      delay(1000);
      PORTD = (PORTD & B00001111) | B01010000;
      
    }
    PORTB = (1<<Phase[i][0]) | (1 << Phase[i][1]);
    PORTC = 1<<Phase[i][2];
    switch(Phase[i][4]){
      case 1: PORTB |= B00000100;break;
      case 2: PORTB |= B00100000;break;
      case 3: PORTC |= B00000100;break;
    }
    delay(Phase[i][3]*100);
  }
}
void request() {
  
  Serial.print("HI");
  r = 1;
}
